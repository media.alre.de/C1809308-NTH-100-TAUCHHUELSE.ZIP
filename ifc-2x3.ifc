Properties of the parts of a building model (IFC2X3)

# File
Description: Tauchhülse, 100 mm, V4A (1.4571), Durchmesser InnenxAußen 8 x 10 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809308, Tauchhülse, 100 mm, V4A (1.4571), Durchmesser InnenxAußen 8 x 10 mm
In: Raum
Description: Tauchhülse, 100 mm, V4A (1.4571), Durchmesser Innen x Außen 8 x 10 mm. Für Fühler mit Durchmesser 7,7 mm, Kapillarthermostate JET / JMT / WR 81.; Classification: EC010502 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809308; ModelLabel: NTH-100; GlobalTradeItemNumber: 4050528018274; ProductURL: https://alre.de/produkt_C1809308
Pset_Specification - NominalLength: 0.118 m; NominalWidth: 0.022 m; NominalDepth: 0.022 m; NetWeight: 0.082
Pset_ALRE_ETIM_Properties - Außendurchmesser: 10; Innendurchmesser: 8; Werkstoffgüte: Edelstahl 316 Ti (1.4571); Druckstufe Artikel: PN 40; Material Tauchrohr: rostfreier Stahl; Einstecklänge: 100; Nenndurchmesser Anschluss: 1/2 Zoll (15); ETIM-Klasse: EC010502; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809308.pdf
